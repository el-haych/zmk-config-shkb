## boards/shields/shkb_xl/Kconfig.defconfig
```kconfig
if SHIELD_SHKB_XL

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "SHKB XL"

endif
```
